# Keil uVision project Bootloader_Ymodem.uvprojx, settings and files
target Bootloader_Ymodem (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Shatang +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\Board_Supports_Package\TIMER;..\Board_Supports_Package\UART1;..\Ymodem
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../Board_Supports_Package/TIMER/: Timer_Driver.c
    ../Board_Supports_Package/UART1/: Rs485_Uart1_Driver.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_flash.c
  group Ymodem
    ../Ymodem/: common.c download.c flash_if.c ymodem.c
  group README
    ../: readme.txt
